# Keil uVision project TOPWAY-Qixing32.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOPWAY-Qixing32 +hex
  c flags: Optim=7 v6Lang=1 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\Libraries\Hardware;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Hardware;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../USER/: stm32f10x_it.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Hardware
    ../Hardware/: Action.c Delay.c Global.c Gpio.c PS2.c Rcc.c Timer.c Usart.c W25q64.c Kinematics.c Color.c
  group USER
    ../USER/: Main.c Sensor.c
software components: CMSIS:CORE 6.2.0
